# IAR project cobra_sys.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303RE ST STM32F303RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F303xE
  ICCARM.CCIncludePath2: CMSIS\Include; CMSIS\STM32F30x\Include; Driver\I2C_CPAL_Driver\inc; Driver\StdPeriph_Driver\inc; User\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cobra_sys.hex
  ILINK.IlinkOutputFile: cobra_sys.out
  ILINK.IlinkIcfFile: Linker\stm32f303xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Application/EWARM
    CMSIS/STM32F30x/Source/: startup_stm32f303xe.s
  group Application/Linker
    Linker/: stm32f303xe_flash.icf
  group Application/User
    User/src/: cobra_button.c cobra_cmd.c cobra_console.c cobra_event.c cobra_led.c cobra_list.c cobra_sys.c cobra_timer.c main.c mod_power.c stm32f30x_it.c system_stm32f30x.c
  group Drivers/StdPeriph
    Driver/StdPeriph_Driver/src/: stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_misc.c stm32f30x_rcc.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c
